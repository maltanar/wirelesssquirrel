<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\WiSq_Collection_Node.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Devices</name>
       <member>
        <project>WiSq_Collection_Node</project>
        <configuration>CC1110-EndDevice</configuration>
      </member>
	  <member>
        <project>WiSq_Collection_Node</project>
        <configuration>CC2430-EndDevice</configuration>
      </member>
	  <member>
        <project>WiSq_Collection_Node</project>
        <configuration>CC2510-EndDevice</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


